# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\hardware\DHT11;.\hardware\OLED;.\hardware;.\hardware\more;.\hardware\HX711;.\hardware\DS18B20;.\hardware\AD;.\hardware\LED
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c
  group hardware
    ./hardware/src/: delay.c usart.c sys.c
    ./hardware/DHT11/: dht11.c
    ./hardware/OLED/: OLED.c
    ./hardware/AD/: AD.c AD.h
    ./hardware/LED/: led.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: onenet.c hmac_sha1.c base64.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
software components: CMSIS:CORE 5.5.0
